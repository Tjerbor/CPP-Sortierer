# Keil uVision project STM32L1xx.uvprojx, settings and files
target Target (6190000::V6.19::ARMCLANG)
  device: STM32L100RCTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: COMPILER_KEIL, MCU_STM32L100xC, OSCSRC=HSE_BYPASS, OSCFREQ=8000
  c misc: -fno-exceptions -Wno-pragma-pack
  c include: .\..\..\..\Src;.\..\..\..\Src\Board\STM32L100-Discovery;{EMBSYSLIB}\Src;{EMBSYSLIB}\Src\Hardware\MCU\STM32L1xx;{EMBSYSLIB}\Src\Hardware\MCU\STM32L1xx\Sys\Keil
  asm define: Stack_Size=0xC00, Heap_Size=0x0C00
  asm include: {EMBSYSLIB}\Src\Hardware\MCU\STM32L1xx\Sys\Keil
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Source
    ./../../../Src/: main.cpp lib.cpp
    ../../../Src/Board/STM32L100-Discovery/: board_pinout.txt
  group Header
    ./../../../Src/Board/STM32L100-Discovery/: ReportHandler.h
  group Assembler
    ./: startup.S
